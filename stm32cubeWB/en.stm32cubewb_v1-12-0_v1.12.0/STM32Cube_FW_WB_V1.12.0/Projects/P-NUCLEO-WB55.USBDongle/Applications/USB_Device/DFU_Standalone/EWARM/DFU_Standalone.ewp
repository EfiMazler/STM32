# IAR project DFU_Standalone.ewp, settings and files
configuration DFU_Standalone (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55CG ST STM32WB55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../USB_Device/App; ../USB_Device/Target; ../Core/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DFU_Standalone.hex
  ILINK.IlinkOutputFile: DFU_Standalone.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usbd_desc.c usbd_dfu_flash.c usb_device.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/BSP/STM32WBxx_Usb_Dongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Middlewares/USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
