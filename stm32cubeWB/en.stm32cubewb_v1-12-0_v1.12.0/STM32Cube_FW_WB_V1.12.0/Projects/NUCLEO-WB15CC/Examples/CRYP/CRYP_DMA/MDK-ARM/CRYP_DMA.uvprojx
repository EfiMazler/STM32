# Keil uVision project CRYP_DMA.uvprojx, settings and files
target CRYP_DMA (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32WB15CCUx STMicroelectronics
  pack: Keil.STM32WB1x_DFP.0.0.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x804FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CRYP_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB15xx,__DBG_ITM
  c include: ../Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/NUCLEO-WB15CC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: stm32wb15xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
    ./: Retarget.c Serial.c
  group Doc
    ../: readme.txt Expected_Results.txt
  group Drivers/BSP/NUCLEO-WB15CC
    ../../../../../../Drivers/BSP/NUCLEO-WB15CC/: nucleo_wb15cc.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 4.3.0
