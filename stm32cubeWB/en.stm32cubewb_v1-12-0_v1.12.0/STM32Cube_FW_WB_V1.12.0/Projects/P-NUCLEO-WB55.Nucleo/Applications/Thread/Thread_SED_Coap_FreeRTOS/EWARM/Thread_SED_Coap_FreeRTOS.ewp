# IAR project Thread_SED_Coap_FreeRTOS.ewp, settings and files
configuration Thread_SED_Coap_FreeRTOS (ARM)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; USE_STM32WBXX_NUCLEO; THREAD_WB; STM32WB55xx; OPENTHREAD_CONFIG_FILE=<openthread_api_config_mtd.h>
  ICCARM.CCIncludePath2: ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo; ../Core/Inc; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread/platform; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include; ../../../../../../Middlewares/ST\STM32_USB_Device_Library/Class/CDC/Inc; ../../../../../../Middlewares/ST\STM32_USB_Device_Library/Core/Inc; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Thread_SED_Coap_FreeRTOS.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wbxx_it.c stm32wbxx_hal_msp.c app_freertos.c hw_timerserver.c hw_uart.c stm32_lpm_if.c freertos_port.c stm_logging.c stm32wbxx_hal_timebase_tim.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_thread.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c tl_thread_hci.c shci_tl.c shci_tl_if.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/: CMakeLists.txt
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: border_agent.c border_router.c channel_manager.c channel_monitor.c child_supervision.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c diag.c dns.c entropy.c errors.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_raw.c logging.c message.c netdata.c network_time.c openthread.c openthread_api_wb.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c tasklet.c thread.c thread_ftd.c udp.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/thread/openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: border_agent.c border_router.c channel_manager.c channel_monitor.c child_supervision.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c diag.c dns.c entropy.c errors.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_raw.c logging.c message.c netdata.c network_time.c openthread.c openthread_api_wb.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c tasklet.c thread.c thread_ftd.c udp.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
