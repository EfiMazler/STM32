# Keil uVision project BLE_HeartRateFreeRTOS_ANCS.uvprojx, settings and files
target BLE_HeartRateFreeRTOS_ANCS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BLE_HeartRateFreeRTOS_ANCS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_STM32WBXX_NUCLEO,STM32WB55xx,USE_HAL_DRIVER,CORE_CM4
  c misc: --diag_suppress 1296
  c include: ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/ble;../Core/Inc;../STM32_WPAN/app;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/Core
    ../Core/Src/: app_debug.c app_entry.c freertos_port.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c stm32wbxx_it.c
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/App/: ancs_client_app.c app_ble.c dis_app.c hrs_app.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: dis.c hrs.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Middlewares/Third_Party/FreeRTOS/Source
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 4.3.0
