# Keil uVision project Zigbee_OnOff_Client_Router_Ota.uvprojx, settings and files
target Zigbee_OnOff_Client_Router_Ota (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IROM(0x08030000-0x807FFFF) IRAM(0x20000004-0x2002EC03) IRAM2(0x20030000-0x20030FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Zigbee_OnOff_Client_Router_Ota +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx,USE_STM32WBXX_NUCLEO,ZIGBEE_WB
  c misc: --diag_suppress 1296
  c include: ../Core/Inc;../STM32_WPAN/App;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/Inc;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/platform;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/mac;../../../../../../Drivers/CMSIS/Include;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm
  library: MicroLIB
  memory RVCT4: ROM 0x8030000 size 0x50000
  memory RVCT9: RAM 0x20000004 size 0x2ec00
  memory RVCT10: RAM 0x20030000 size 0x1000
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c stm_logging.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_zigbee.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WBxx_Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/schi
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_zigbee_hci.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Middlewares/STM32_WPAN/zigbee/core
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/src/: zigbee_core_wb.c
  group Middlewares/STM32_WPAN/zigbee/platform
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/platform/: ee.c hw_flash.c
  group Middlewares/STM32_WPAN/zigbee/stack
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/lib/: stm32wb_zigbee_wb_lib_keil.lib
  group Utilities/lpm/tiny_lpm
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Utilities/sequencer
    ../../../../../../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 4.3.0
