# Keil uVision project Mac_802_15_4_FFD_Demo.uvprojx, settings and files
target P-NUCLEO-WB55.Nucleo_Mac_802_15_4_FFD_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.6
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20020000-0x2002FFFF) IRAM2aRet_SHARED(0x20030000-0x20033FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Mac_802_15_4_FFD_Demo
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,USE_STM32WBXX_NUCLEO,STM32WB55xx,MAC_802_15_4_WB
  c misc: --C99
  c include: ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/;../Core/Inc;../STM32_WPAN/app;../STM32_WPAN/Target;../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20020000 size 0x10000
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_entry.c stm32_lpm_if.c hw_uart.c main.c stm32wbxx_it.c stm_logging.c system_stm32wbxx.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/app/: app_ffd_mac_802_15_4.c app_ffd_mac_802_15_4_process.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/mac_802_15_4/inc
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc/: 802_15_4_mac_config.h 802_15_4_mac_core.h 802_15_4_mac_errors.h 802_15_4_mac_sap.h 802_15_4_mac_types.h
  group Middlewares/STM32_WPAN/mac_802_15_4/src
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/src/: mac_802_15_4_core_wb.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
